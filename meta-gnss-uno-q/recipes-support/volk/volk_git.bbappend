# VOLK, the vector library under GNU Radio: the release that goes with it.
#
# meta-sdr builds a snapshot of VOLK's main branch. This image uses release
# v3.2.0, the version the receiver was validated with on this board together
# with GNU Radio 3.10.12.0 (docs/logs/board-inventory-20261115). ADR-002.
# meta-sdr's two patches apply to v3.2.0 unchanged (checked 2026-11-15).
PV = "3.2.0"
# Tag v3.2.0, on the main branch.
SRCREV = "308948abf8384bb4bf6467e14b585df708789782"
